Commit message: working on inverse kinematic

File: utils/models/short_floor.urdf (robot description, URDF)
Before this commit: robot flat_terrain, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=2 2 0.1; visual box size=10 10 0.1
